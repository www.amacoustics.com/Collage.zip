Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_Collage-by-AM-Acoustics.ifc
Time: 2020-01-15T09:47:17
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Collage by AM Acoustics
ePset_BIMobjectScript - Size: 600 x 600; Textile: HUSH Red; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Collage by AM Acoustics; SKU (BO_prodsku): collage; ManufacturName (BO_Manufac): Akustikmiljö; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Wall and Ceiling Acoustics; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 50; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/collage; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/collage; ProductUrl (BO_producturl): https://www.gotessons.com/en/whiteboard-notice-board/collage-ecosund; ProductCertification (BO_prodcert): https://www.gotessons.com/en/quality-and-environment/; TechnicalDescription (BO_techcert): https://www.gotessons.com/storage/3896AB3155C11CA8B21930B67D2261BEEB4BA224D50F67A5CBDB7BAF32BEE024/875a3ad86c5e43ef92ecbc917bb11c7a/pdf/media/e14d7144d50146009172bc3d44a706e8/125700-_ritning.pdf; MaterialMain (BO_mainmat): Polyester; MaterialSecondary (BO_secmat): Polyester; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass2015Code (BO_uniclass2015_code): EF_40_30; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): SE
